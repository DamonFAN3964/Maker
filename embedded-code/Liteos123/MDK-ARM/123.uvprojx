# Keil uVision project 123.uvprojx, settings and files
target 123 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 123 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Core/LiteOS/arch/arm/arm-m/include;../Core/LiteOS/kernel/include;../Core/LiteOS/kernel/base/include;../Core/LiteOS/kernel/extended/include;../Core/LiteOS/OS_CONFIG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ./: usart.c
    ../Core/Src/: main.c gpio.c adc.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group LiteOS/Arch
    ../Core/LiteOS/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../Core/LiteOS/arch/arm/arm-m/cortex-m3/keil/: los_dispatch_keil.S
  group LiteOS/Kernel
    ../Core/LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../Core/LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../Core/LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../Core/LiteOS/kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../Core/LiteOS/kernel/base/mem/membox/: los_membox.c
    ../Core/LiteOS/kernel/base/misc/: los_misc.c
    ../Core/LiteOS/kernel/base/om/: los_err.c
    ../Core/LiteOS/kernel/extended/tickless/: los_tickless.c
    ../Core/LiteOS/kernel/: los_init.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
